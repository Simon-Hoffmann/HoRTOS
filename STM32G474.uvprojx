# Keil uVision project STM32G474.uvprojx, settings and files
target HoRTOS (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G474VETx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: EBSy_Px
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\System;.\CMSIS
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Sources
    ./: main.c delay.s delay.h delayus.s
  group System
    ./System/: startup_stm32g431xx.s stm32g4xx.h STM32G4xx_REG_ASM.inc stm32g474xx.h system_stm32g4xx.c
    ./: handlers.c handlers.h
  group Hardware
    ./: led.c led.h uart.c uart.h
  group OS
    ./: fifo.h fifo.c tasklist.c tasklist.h task.c task.h os_tasks.c os_tasks.h schedulerASM.s scheduler.c scheduler.h semaphore.c semaphore.h
  group Middleware
    ./: user_tasks.h user_tasks.c cmd.c cmd.h commands.c commands.h
